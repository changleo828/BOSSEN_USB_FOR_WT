# IAR project Backup of 13.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: CC430F5133 CC430F5133
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: Acquisition.h AD7711_ZY1.h AutoZengyi.h Battery.h data.h Define.h Delete.h Demand.h Device_Start.h FAT32.h Help.h HT1621.h Init.h KeyBoard3.h main.c main.h MemoryManagement.h PiecewiseLinear.h PiecewiseLinear_Current.h PositionAUTO.h SD.H Setting.h user.h Vol_Disp2.h Vol_Display.h ZengYi.h
